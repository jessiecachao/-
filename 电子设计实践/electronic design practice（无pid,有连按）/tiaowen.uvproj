# Keil uVision project tiaowen.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: tiaowen +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\usr
  group Source Group 1
    ./: STARTUP.A51
    ./usr/: ds18b20.c ee24c166.c global.c hd7279.c main.c motor.c pid.c
